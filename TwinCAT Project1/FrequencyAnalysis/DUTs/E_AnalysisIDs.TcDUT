TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_Source := 1,
	eID_Spectrum,
	eID_Sink,
	eID_MC,
	eID_BufferConverter,
	eID_SinkMC,
	eID_Classify,
	eID_SinkClassify	
) UDINT;
END_TYPE
